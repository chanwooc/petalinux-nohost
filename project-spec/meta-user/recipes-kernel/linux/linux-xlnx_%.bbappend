SRC_URI += "file://bsp.cfg \
            file://user_2019-07-10-17-51-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
